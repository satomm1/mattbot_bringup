Commit message: Make easy to choose car vs non car launch

File: urdf/robot_tf_car.urdf (robot description, URDF)
Before this commit: robot mattbot, 4 links, 3 joints
Joints:
- joint base_joint: origin xyz=0 0 0.0224 rpy=0 0 0 -> xyz=0.1243076 0 0.0224 rpy=0 0 0
